Commit message: make action simpler with 2 axis forces
Signed-off-by: youliang <tan_you_liang@hotmail.com>

File: tennisbot/resources/racket.urdf (robot description, URDF)
Before this commit: robot racket, 1 links, 0 joints
Links:
- link base_link: mass 0.4 -> 4.0
