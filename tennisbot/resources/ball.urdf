Commit message: update swing racket training
Signed-off-by: youliang <tan_you_liang@hotmail.com>

File: tennisbot/resources/ball.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link ball: mass 1.0 -> 0.05
